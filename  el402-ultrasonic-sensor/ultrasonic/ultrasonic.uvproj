# Keil uVision project ultrasonic.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: ultrasonic
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\libs\STM32F0xx_StdPeriph_Driver\inc;.\libs\STM32F0xx_StdPeriph_Driver\src;.\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ./: startup_stm32f051.s
    ./src/: system_stm32f0xx.c
  group std_periph_driver
    ./libs/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_tim.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_gpio.c stm32f0xx_usart.c
  group main
    ./main/: main.c
  group hal
    ./src/: util.c soniclib.c serial.c
